# Keil uVision project PFPU.uvproj, settings and files
target PROJECT (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: PFPU
  c define: __FPU_PRESENT="1",ARM_MATH_CM4,HSE_VALUE=8000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\OBJ\STM32F4.sct
  group CMSIS Device
    ../: system_stm32f4xx.c startup_stm32f40xx.s
  group CMSIS Lib
    C:/Keil/ARM/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Program
    ../: main.c Adafruit32x16.c
  group Header
    ../: Adapanel.h
